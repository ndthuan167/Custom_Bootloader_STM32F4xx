# Keil uVision project STM32F4xx_Custom_Bootloader.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx_Custom_Bootloader +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c IRQ_Handler.c
    ./Peripheral/GPIO/: GPIO.c
    ./Peripheral/RCC/: RCC.c
    ./Peripheral/SystemTimer/: Systick.c
    ./Peripheral/EXTI/: EXTI.c
    ./Peripheral/NVIC/: NVIC.c
    ./Peripheral/SystemControlBLock/: SCB.c
    ./Peripheral/Timer/: Timer.c
    ./Peripheral/USART/: USART.c
    ./Custom_Bootloader/: Custom_Bootloader.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
